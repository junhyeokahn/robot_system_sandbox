Commit message: Fixed mass matrix error, added atlas directory

File: two_link_manipulator.urdf (robot description, URDF)
Before this commit: robot two_link_robot, 4 links, 3 joints
Links:
- link ground: mass 1. -> 0.0001
